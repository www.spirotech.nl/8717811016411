Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_EP0800R_INT-EN.ifc
Time: 2025-08-05T18:20:18+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN:EP0800R, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN:EP0800R:1783898
In: F00
Type - Material: Color RAL 1003, Color RGB 040-040-040
Type - Other - Category: Mechanical Equipment; Bracket Visibility: yes; Bracket Visibility 2: no; Connection Geometry: Connection_Geometry : EP0800R(S); Connection Visibility: yes; Connection Visibility 2: no; Connection Visibility 3: no; Connection Visibility 4: no; Connection Visibility 5: no; Connector Angle: 270 deg; Drain Geometry: yes; Drain Geometry 2: no; Drain Geometry 3: yes; Drain Position-Back: 333.29 mm; Drain Position-Elevation: 1694.45 mm; Drain Position-Right: 333.29 mm; Drain Revolve Start Angle: 4 deg; EP0200R(S) Expansion Vessel: no; EP0300R(S) Expansion Vessel: no; EP0500R(S) Expansion Vessel: no; EP0800R(S) Expansion Vessel: yes; EP1000R(S) Expansion Vessel: no; EP1500R(S) Expansion Vessel: no; EP2000R(S) Expansion Vessel: no; EP2500R(S) Expansion Vessel: no; EP3000R(S) Expansion Vessel: no; EP4000R(S) Expansion Vessel: no; EP5000R(S) Expansion Vessel: no; EPX100R(S) Expansion Vessel: no; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN; Feet Geometry: Feet_Geometry : EP0800R(S); Nominal Diameter: 25.4 mm; Outer Diameter: 33.7 mm; Upper Geometry: no; X Axis: 345.5 mm; Y Axis: 109.17 mm; Z Axis: 123 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 25.4 mm; Diameter: 800 mm; Drain Diameter: 50 mm; Height: 2110 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Primary Expansion vessels for EMCM & ETCM 800 ltr; Article Type: EP0800R; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Primary Expansion vessels for EMCM & ETCM 800 ltr; EMCS Version: 4.0; ETIM Article Class: EC010958; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811016411; Manufacturer: Spirotech; Manufacturer Art. No.: EP0800R; Manufacturer URL: https://www.spirotech.com/8717811016411; MEPcontent Class: EXPANSIONVESSEL; Model: EP0800R; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EP0800R; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Color: Color RAL 1003
Type - Mechanical - Max. Medium Temperature (continuous): 0 C; Pre-pressure: 0; Volume: 0.8 m3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EP0800R; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EP0800R
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN: EP0800R; Type: EP0800R; Type Id: 1783852
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 76.341 m2; Volume: 0.861252 m3
Identity Data - Mark: 4
Mechanical - Flow 1: 0 m3/s; Flow 2: 0 m3/s; System Classification: Undefined,Sanitary
Mechanical - Flow - Drain Fixture Units: 0
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (3)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
OutPort_1783898_1 | SOURCE
InPort_1783898_2 | SINK
OutPort_1783898_3 | SOURCE | SystemType: SEWAGE
